# Repository chenxuuu/BT-MP3

## KiCad design hardware/bt-mp3/bt-mp3.kicad_pcb

Parts:
AE1: 蓝牙天线; bt_ant_mirror
C1, C2: 10uF; C_0402_1005Metric
C3, C4, C9: NF; C_0402_1005Metric
C5, C13, C14, C15: 4.7uF; C_0402_1005Metric
C6, C7, C8: 2.2uF/10V; C_0402_1005Metric
C10: 4.7uF/10V; C_0402_1005Metric
C11, C12: 1uF; C_0402_1005Metric
C16: 0.47uF; C_0402_1005Metric
C17, C18, C20: 0.1uF; C_0402_1005Metric
D1: RED; LED_0402_1005Metric
D2: WHITE; LED_0402_1005Metric
D3: ESD5311N-2; DFN1006-2_L1.0-W0.6-RD
J1: USB_C_Receptacle_USB2.0_16P; USB_C_Receptacle_GCT_USB4105-xx-A_16P_TopMnt_Horizontal
J2: BATT; Hirose_DF13C_CL535-0402-2-51_1x02-1MP_P1.25mm_Vertical
J3: LCD; 1.47LCD-IPS-172x320-font
J4: TF-021B-H265; TF-SMD_TF-021B-H265
L1: 4.7uH; L_Murata_DFE201610P
Q1, Q2: SS8050; SOT-23
R1, R2, R7, R9, R21: 5.1K; R_0402_1005Metric
R3: 0R; R_0402_1005Metric
R4, R23: 1K; R_0402_1005Metric
R6: 10K; R_0402_1005Metric
R8: 10R; R_0402_1005Metric
R10, R13, R14, R15, R16, R22: 100K; R_0402_1005Metric
R11: 1M; R_0402_1005Metric
R12: 2M; R_0402_1005Metric
SW1, SW3, SW4: Side_SWITCH_SW_3*6*3.5mm; 3x6x3.5_SW_side
SW5: SIQ-02FVS3_1
SW6: SS-22F25-G050; MS-22C01-G010
TP1, TP2, TP3, TP4, TP6, TP7: TestPoint; TestPoint_Pad_D1.5mm
U1: SF32LB527UD6; ArtInChip_QFN-68-1EP_7x7mm_P0.35mm_EP5.49x5.49mm
U2: PY25Q128HA-WXH-IR; SOIC-8_5.23x5.23mm_P1.27mm
Y1: 48M; Crystal_SMD_2016-4Pin_2.0x1.6mm
Y2: 32.768KHz/7pF; Crystal_SMD_3215-2Pin_3.2x1.5mm

Connections:
+BATT: J2.1, R11.1, SW6.1, SW6.4, U1.20 (BAT)
/BAT_ADC: C20.1, R11.2, R12.1, U1.2 (PA31)
/DBG_RX: TP3.1, U1.27 (PA18)
/DBG_TX: TP2.1, U1.26 (PA19)
/KEY1: SW3.1, U1.44 (PA7)
/KEY2: SW4.1, U1.49 (PA2)
/KEY3: SW5.S, U1.42 (PA9)
/KEYA: SW5.A, U1.43 (PA8)
/KEYB: SW5.B, U1.35 (PA10)
/LCD_LED_PWM: R9.1, U1.50 (PA1)
/PA00_LCD_RESET: J3.11, U1.51 (PA0)
/PA03_LCD_CS: J3.8, U1.48 (PA3)
/PA04_LCD_SCL: J3.9, U1.47 (PA4)
/PA05_LCD_DAT: J3.10, U1.46 (PA5)
/PA06_LCD_DC: J3.7, U1.45 (PA6)
/PA34_POWER_KEY: D3.2 (A2), R6.2, SW1.1, U1.66 (PA34)
/PA_12_MPI2_CS: U1.33 (PA12), U2.1 (~CS)
/PA_13_MPI2_D1: U1.32 (PA13), U2.2 (DO(IO1))
/PA_14_MPI2_D2: U1.31 (PA14), U2.3 (IO2)
/PA_15_MPI2_D0: U1.30 (PA15), U2.5 (DI(IO0))
/PA_16_MPI2_CLK: U1.29 (PA16), U2.6 (CLK)
/PA_17_MPI2_D3: U1.28 (PA17), U2.7 (IO3)
/TF_SPI_CLK: J4.5 (CLK), R15.1, U1.5 (PA28)
/TF_SPI_CS: J4.2 (DAT3/CD), R13.1, U1.4 (PA29)
/TF_SPI_MISO: J4.7 (DAT0), R16.1, U1.8 (PA25)
/TF_SPI_MOSI: J4.3 (CMD), R14.1, U1.9 (PA24)
/USB_DM: J1.A7 (D-), J1.B7 (D-), U1.64 (PA36)
/USB_DP: J1.A6 (D+), J1.B6 (D+), U1.65 (PA35)
/WHITE_LED: R21.1, U1.34 (PA11)
GND: AE1.2 (Shield), C1.1, C2.1, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C20.2, D1.1 (K), D3.1 (A1), J1.A1 (GND), J1.A12 (GND), J1.B1 (GND), J1.B12 (GND), J1.S1 (SHIELD), J2.2, J3.1, J3.5, J3.6, J3.12, J4.6 (VSS), J4.9 (SHIELD), J4.10 (SHIELD), Q1.2 (E), Q2.2 (E), R1.2, R2.1, R6.1, R10.1, R12.2, R22.1, SW1.3, SW3.2, SW3.3, SW4.2, SW4.3, SW5.1 (EH), SW5.2 (EH), SW5.3 (EH), SW5.4 (EH), SW5.5 (EH), SW5.6 (EH), SW5.C, TP1.1, U1.69 (GND), U2.4 (GND), Y1.2, Y1.4
unnamed: AE1.1 (A), C4.1, R3.1
unnamed: D1.2 (A), R4.2
unnamed: D2.1 (K), R23.2
unnamed: J1.A5 (CC1), R1.1
unnamed: J1.B5 (CC2), R2.2
unnamed: J3.2, R8.2
unnamed: Q1.1 (B), R9.2, R10.2
unnamed: Q1.3 (C), R8.1
unnamed: Q2.1 (B), R21.2, R22.2
unnamed: Q2.3 (C), R23.1
unnamed: R7.2, SW1.2
unnamed: C10.1, L1.2, U1.17 (BUCK_FB)
unnamed: C9.1, L1.1, U1.18 (BUCK_LX)
unnamed: C14.1, U1.68 (GPADC_VREF)
unnamed: C2.2, SW6.2, SW6.5, U1.24 (VCC)
unnamed: C11.1, U1.23 (VDD18_VOUT)
unnamed: C16.1, U1.13 (VDD_RET)
unnamed: C12.1, U1.12 (VDD_RTC)
unnamed: C13.1, U1.16 (VDD_VOUT1)
unnamed: C15.1, U1.15 (VDD_VOUT2)
unnamed: C3.1, R3.2, U1.53 (ANT)
unnamed: U1.11 (PA22), Y2.1
unnamed: U1.10 (PA23), Y2.2
unnamed: U1.55 (XTAL48M_XI), Y1.3
unnamed: U1.54 (XTAL48M_XO), Y1.1
VBUS: C1.2, J1.A4 (VBUS), J1.A9 (VBUS), J1.B4 (VBUS), J1.B9 (VBUS), R4.1, U1.21 (VBUS)
VDD33_VOUT1: C7.1, C17.1, D2.2 (A), J3.3, J3.4, TP7.1, U1.22 (VDD33_VOUT1), U2.8 (VCC)
VDD33_VOUT2: C8.1, C18.1, J4.4 (VDD), R13.2, R14.2, R15.2, R16.2, TP6.1, U1.14 (VDD33_VOUT2)
VSYS: C5.1, C6.1, R7.1, TP4.1, U1.19 (VSYS), U1.52 (AVDD_BRF)

Notes on the sheet:
开机键
USB口
USB指示灯
旋转编码器+按键
电源检查
按键2
充电状态灯 呼吸灯
电池电压检测
PWM调背光
调试下载
按键1
主FLASH

Board: 2 copper layers, 59.9 x 30.0 mm, 63 parts (1 on the bottom side), 59 nets.

## Commit log

2025-02-03 add: 先摆几个元器件
2025-02-05 add: 基础的外围器件
2025-02-06 update: 完成原理图
2025-02-06 add: 原理图信息
2025-02-10 update: 分配好封装
2025-02-10 add: 布线
